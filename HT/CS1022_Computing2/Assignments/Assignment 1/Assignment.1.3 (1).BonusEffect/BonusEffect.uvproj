# Keil uVision project BonusEffect.uvproj, settings and files
target External SDRAM (5050169::V5.05 update 2 (build 169)::.\ARMCC_505u2)
  device: LPC2468 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x4000FFFF) IRAM2(0x7FE00000-0x7FE03FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: BonusEffect
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: .\LCD
  asm define: NO_CLOCK_SETUP NO_EMC_SETUP RAM_INTVEC RAM_MODE REMAP
  library: MicroLIB
  memory RVCT1: ROM 0xa0000000 size 0x1000000
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT6: RAM 0xa1000000 size 0x1000000
  memory RVCT9: RAM 0x40000000 size 0x10000
  memory RVCT10: RAM 0x7fe00000 size 0x4000
  group Support Files
    ./LCD/: font5x7.c lcd_grph.c lcd_hw.c config.h font_macro.h font5x7.h general.h lcd_grph.h lcd_hw.h
    ./support/: crest.h Retarget.c Serial.c LPC2400.s main.c
  group Application Code
    ./: BonusEffect.s
target Simulator (5050169::V5.05 update 2 (build 169)::.\ARMCC_505u2)
  device: LPC2468 NXP (founded by Philips)
  cpu: as above
  output: BonusEffect
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: .\LCD
  asm define: NO_CLOCK_SETUP NO_EMC_SETUP RAM_INTVEC RAM_MODE REMAP
  library: MicroLIB
  memory RVCT1: ROM 0xa0000000 size 0x1000000
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT6: RAM 0xa1000000 size 0x1000000
  memory RVCT9: RAM 0x40000000 size 0x10000
  memory RVCT10: RAM 0x7fe00000 size 0x4000
